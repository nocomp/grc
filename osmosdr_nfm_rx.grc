<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import math</value></param>
</block>
<block>
<key>gr_freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>xlating_fir_filter</value></param>
<param><key>type</key><value>ccf</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>taps</key><value>xlate_filter_taps</value></param>
<param><key>center_freq</key><value>-(rx_coarse+rx_fine)</value></param>
<param><key>samp_rate</key><value>s_rate</value></param>
</block>
<block>
<key>blks2_nbfm_rx</key>
<param><key>id</key><value>nbfm_normal</value></param>
<param><key>audio_rate</key><value>48000</value></param>
<param><key>quad_rate</key><value>48000</value></param>
<param><key>tau</key><value>50e-6</value></param>
<param><key>max_dev</key><value>12500</value></param>
</block>
<block>
<key>gr_pwr_squelch_xx</key>
<param><key>id</key><value>gr_pwr_squelch_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>threshold</key><value>sql_lev</value></param>
<param><key>alpha</key><value>1</value></param>
<param><key>ramp</key><value>1</value></param>
<param><key>gate</key><value>True</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>rf_pwr_lvl</value></param>
<param><key>value</key><value>0</value></param>
<param><key>block_id</key><value>rf_input</value></param>
<param><key>function_name</key><value>rssi</value></param>
<param><key>poll_rate</key><value>5</value></param>
</block>
<block>
<key>gr_probe_avg_mag_sqrd_x</key>
<param><key>id</key><value>rf_input</value></param>
<param><key>type</key><value>c</value></param>
<param><key>threshold</key><value>-20</value></param>
<param><key>alpha</key><value>1.0/(s_rate/2)</value></param>
</block>
<block>
<key>gr_fractional_interpolator_xx</key>
<param><key>id</key><value>gr_fractional_interpolator_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>phase_shift</key><value>0</value></param>
<param><key>interp_ratio</key><value>5.833333</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>decim</key><value>10</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>s_rate</value></param>
<param><key>cutoff_freq</key><value>width</value></param>
<param><key>width</key><value>trans</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>xlate_filter_taps</value></param>
<param><key>value</key><value>firdes.low_pass(1, s_rate, 125000, 25000, firdes.WIN_HAMMING, 6.76)</value></param>
</block>
<block>
<key>osmosdr_source_c</key>
<param><key>id</key><value>osmosdr_source_c_0</value></param>
<param><key>args</key><value></value></param>
<param><key>freq</key><value>rx_freq</value></param>
<param><key>corr</key><value>0</value></param>
<param><key>rate</key><value>s_rate</value></param>
<param><key>gain</key><value>rf_gain</value></param>
<param><key>antenna</key><value></value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>rx_fine</value></param>
<param><key>label</key><value>RX Fine</value></param>
<param><key>value</key><value>0</value></param>
<param><key>min</key><value>-1000</value></param>
<param><key>max</key><value>1000</value></param>
<param><key>num_steps</key><value>400</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>1,4,1,4</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>rf_gain</value></param>
<param><key>label</key><value>RF Gain</value></param>
<param><key>value</key><value>20</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>50</value></param>
<param><key>num_steps</key><value>50</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>1,8,1,4</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>rx_freq</value></param>
<param><key>label</key><value>RX Center </value></param>
<param><key>value</key><value>freq</value></param>
<param><key>min</key><value>70000000</value></param>
<param><key>max</key><value>1070000000</value></param>
<param><key>num_steps</key><value>1000</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>0,0,1,16</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>rx_freq_val</value></param>
<param><key>label</key><value>Receive</value></param>
<param><key>value</key><value>rx_freq+(rx_coarse+rx_fine)</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>formatter</key><value>None</value></param>
<param><key>grid_pos</key><value>0,16,1,1</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>af_gain</value></param>
<param><key>label</key><value>VOL</value></param>
<param><key>value</key><value>1</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>5</value></param>
<param><key>num_steps</key><value>50</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>2,12,1,4</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>trans</value></param>
<param><key>label</key><value>LP Trans</value></param>
<param><key>value</key><value>25000</value></param>
<param><key>min</key><value>500</value></param>
<param><key>max</key><value>50000</value></param>
<param><key>num_steps</key><value>900</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>2,8,1,4</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>sql_lev</value></param>
<param><key>label</key><value>SQL</value></param>
<param><key>value</key><value>-20</value></param>
<param><key>min</key><value>-100</value></param>
<param><key>max</key><value>100</value></param>
<param><key>num_steps</key><value>200</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>1,12,1,4</value></param>
</block>
<block>
<key>variable_static_text</key>
<param><key>id</key><value>rf_pwr_txt</value></param>
<param><key>label</key><value>RF Power </value></param>
<param><key>value</key><value>10.0*math.log(rf_pwr_lvl+1.0e-11)/math.log(10)</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>formatter</key><value>lambda x: "%4.1f" % x</value></param>
<param><key>grid_pos</key><value>1,16,1,1</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0</value></param>
<param><key>samp_rate</key><value>48000</value></param>
<param><key>num_inputs</key><value>2</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>width</value></param>
<param><key>label</key><value>LP Filter</value></param>
<param><key>value</key><value>12500</value></param>
<param><key>min</key><value>2000</value></param>
<param><key>max</key><value>40000</value></param>
<param><key>num_steps</key><value>760</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>2,4,1,4</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq</value></param>
<param><key>value</key><value>145000000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>s_rate</value></param>
<param><key>value</key><value>2800000</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>rx_coarse</value></param>
<param><key>label</key><value>RX Offset</value></param>
<param><key>value</key><value>250000</value></param>
<param><key>min</key><value>-500000</value></param>
<param><key>max</key><value>500000</value></param>
<param><key>num_steps</key><value>960</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>1,0,1,4</value></param>
</block>
<block>
<key>notebook</key>
<param><key>id</key><value>Main</value></param>
<param><key>style</key><value>wx.NB_TOP</value></param>
<param><key>labels</key><value>['Waterfall', 'Spectrum']</value></param>
<param><key>grid_pos</key><value>4,0,1,17</value></param>
</block>
<block>
<key>wxgui_waterfallsink2</key>
<param><key>id</key><value>wxgui_waterfallsink2_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value>Spectrum Overview</value></param>
<param><key>samp_rate</key><value>s_rate</value></param>
<param><key>baseband_freq</key><value>rx_freq</value></param>
<param><key>dynamic_range</key><value>90</value></param>
<param><key>ref_level</key><value>-20</value></param>
<param><key>ref_scale</key><value>2.0</value></param>
<param><key>fft_size</key><value>2048</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>average</key><value>False</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>win</key><value>window.hamming</value></param>
<param><key>win_size</key><value>800,500</value></param>
<param><key>notebook</key><value>Main,0</value></param>
</block>
<block>
<key>wxgui_fftsink2</key>
<param><key>id</key><value>fftsink_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>title</key><value></value></param>
<param><key>samp_rate</key><value>s_rate/10</value></param>
<param><key>baseband_freq</key><value>rx_freq*fft_disp</value></param>
<param><key>y_per_div</key><value>10</value></param>
<param><key>y_divs</key><value>5</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>ref_scale</key><value>2</value></param>
<param><key>fft_size</key><value>2048</value></param>
<param><key>fft_rate</key><value>15</value></param>
<param><key>peak_hold</key><value>True</value></param>
<param><key>average</key><value>False</value></param>
<param><key>avg_alpha</key><value>0.5</value></param>
<param><key>win</key><value>None</value></param>
<param><key>win_size</key><value>800,500</value></param>
<param><key>notebook</key><value>Main,1</value></param>
</block>
<block>
<key>variable_chooser</key>
<param><key>id</key><value>fft_disp</value></param>
<param><key>label</key><value>FFT</value></param>
<param><key>value</key><value>0</value></param>
<param><key>choices</key><value>[0,1]</value></param>
<param><key>labels</key><value>['Baseband','OsmoSDR']</value></param>
<param><key>type</key><value>radio_buttons</value></param>
<param><key>style</key><value>wx.RA_HORIZONTAL</value></param>
<param><key>grid_pos</key><value>2,0,1,4</value></param>
</block>
<block>
<key>options</key>
<param><key>id</key><value>osmo_nfm_rx</value></param>
<param><key>title</key><value>OSMOSDR NFM RX</value></param>
<param><key>description</key><value>https://apollo.open-resource.org/mission:log:2012:05:06:rtlsdr-osmosdr-gnuradio-fm-receiver</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>gr_multiply_const_vxx</key>
<param><key>id</key><value>gr_multiply_const_vxx_1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>const</key><value>af_gain</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gr_wavfile_sink</key>
<param><key>id</key><value>gr_wavfile_sink_0</value></param>
<param><key>file</key><value>/tmp/gr-output.wav</value></param>
<param><key>nchan</key><value>2</value></param>
<param><key>samp_rate</key><value>48000</value></param>
<param><key>bits_per_sample</key><value>16</value></param>
</block>
<connection><source_block_id>low_pass_filter</source_block_id><sink_block_id>gr_fractional_interpolator_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter</source_block_id><sink_block_id>rf_input</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>xlating_fir_filter</source_block_id><sink_block_id>low_pass_filter</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_c_0</source_block_id><sink_block_id>wxgui_waterfallsink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_fractional_interpolator_xx_0</source_block_id><sink_block_id>fftsink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_c_0</source_block_id><sink_block_id>xlating_fir_filter</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>nbfm_normal</source_block_id><sink_block_id>gr_multiply_const_vxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_multiply_const_vxx_1</source_block_id><sink_block_id>audio_sink_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>gr_multiply_const_vxx_1</source_block_id><sink_block_id>audio_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_pwr_squelch_xx_0</source_block_id><sink_block_id>nbfm_normal</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_fractional_interpolator_xx_0</source_block_id><sink_block_id>gr_pwr_squelch_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_multiply_const_vxx_1</source_block_id><sink_block_id>gr_wavfile_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_multiply_const_vxx_1</source_block_id><sink_block_id>gr_wavfile_sink_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
</flow_graph>
