<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>WBFM_Transmitter</value></param>
<param><key>author</key><value>Scott Jordan</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>description</key><value>Transmits WBFM from pc audio</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>realtime_scheduling</key><value>1</value></param>
<param><key>title</key><value>WBFM Transmitter</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>adj</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>0</value></param>
<param><key>grid_pos</key><value>2, 1, 1, 1</value></param>
<param><key>label</key><value>Fine Transmit Adj.</value></param>
<param><key>max</key><value>200000</value></param>
<param><key>min</key><value>-200000</value></param>
<param><key>num_steps</key><value>1000</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>aud_gain</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>3</value></param>
<param><key>grid_pos</key><value>6, 1, 1, 1</value></param>
<param><key>label</key><value>Audio Input Gain</value></param>
<param><key>max</key><value>100</value></param>
<param><key>min</key><value>1</value></param>
<param><key>num_steps</key><value>1000</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>audio_deci</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>1</value></param>
<param><key>grid_pos</key><value>7, 1, 1, 1</value></param>
<param><key>label</key><value>Input Audio Decimation</value></param>
<param><key>max</key><value>20</value></param>
<param><key>min</key><value>0</value></param>
<param><key>num_steps</key><value>1000</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>bb_gain</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>50</value></param>
<param><key>grid_pos</key><value>5, 1, 1, 1</value></param>
<param><key>label</key><value>BB Gain</value></param>
<param><key>max</key><value>100</value></param>
<param><key>min</key><value>0</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>freq</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>96100000</value></param>
<param><key>grid_pos</key><value>1, 1, 1, 1</value></param>
<param><key>label</key><value>Transmit Frequency</value></param>
<param><key>max</key><value>108100000</value></param>
<param><key>min</key><value>88100000</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>if_gain</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>50</value></param>
<param><key>grid_pos</key><value>4, 1, 1, 1</value></param>
<param><key>label</key><value>IF Gain</value></param>
<param><key>max</key><value>100</value></param>
<param><key>min</key><value>0</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>rf_gain</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>64</value></param>
<param><key>grid_pos</key><value>3, 1, 1, 1</value></param>
<param><key>label</key><value>RF Gain</value></param>
<param><key>max</key><value>100</value></param>
<param><key>min</key><value>0</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>audio_source</key>
<param><key>id</key><value>audio_source_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>samp_rate</key><value>32000</value></param>
</block>
<block>
<key>baz_file_source</key>
<param><key>id</key><value>baz_file_source_0</value></param>
<param><key>auto_load</key><value>True</value></param>
<param><key>file</key><value></value></param>
<param><key>files</key><value>[]</value></param>
<param><key>item_size</key><value>0</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>pad</key><value>False</value></param>
<param><key>repeat</key><value>True</value></param>
<param><key>samp_rate</key><value>0</value></param>
<param><key>timing_file</key><value></value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blks2_wfm_tx</key>
<param><key>id</key><value>blks2_wfm_tx_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>audio_rate</key><value>10000</value></param>
<param><key>max_dev</key><value>75e3</value></param>
<param><key>quad_rate</key><value>600000</value></param>
<param><key>tau</key><value>75e-6</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0</value></param>
<param><key>cutoff_freq</key><value>15000</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>fir_filter_fff</value></param>
<param><key>gain</key><value>aud_gain</value></param>
<param><key>samp_rate</key><value>32000</value></param>
<param><key>width</key><value>10000</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>osmosdr_sink_c</key>
<param><key>id</key><value>osmosdr_sink_c_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>ant0</key><value></value></param>
<param><key>args</key><value></value></param>
<param><key>bb_gain0</key><value>bb_gain</value></param>
<param><key>bw0</key><value>0</value></param>
<param><key>corr0</key><value>0</value></param>
<param><key>freq0</key><value>freq+adj</value></param>
<param><key>gain0</key><value>rf_gain</value></param>
<param><key>if_gain0</key><value>if_gain</value></param>
<param><key>nchan</key><value>1</value></param>
<param><key>sample_rate</key><value>32000</value></param>
<param><key>type</key><value>fc32</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0_0</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
<param><key>bw0</key><value>1000000</value></param>
<param><key>center_freq0</key><value>433.893e6</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>bb_gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value>serial=30C7E1D</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>1000000</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
<param><key>len_tag_name</key><value></value></param>
</block>
<connection><source_block_id>audio_source_0</source_block_id><sink_block_id>low_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>baz_file_source_0</source_block_id><sink_block_id>uhd_usrp_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_wfm_tx_0</source_block_id><sink_block_id>osmosdr_sink_c_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>blks2_wfm_tx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
